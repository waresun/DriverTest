## Kconfig
```kconfig
config HELLO
tristate "First Android Driver"
default n
help
This is brantyou first Android driver.
```
